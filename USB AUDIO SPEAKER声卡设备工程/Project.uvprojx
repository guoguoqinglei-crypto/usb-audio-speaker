# Keil uVision project Project.uvprojx, settings and files
target Target_1 (6150000::V6.15::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Library;.\Start;.\User;.\hardware;.\hardware\TinyUSB;.\hardware\TinyUSB\tinyusb\src;.\hardware\TinyUSB\port;.\Middle\Freertos\source\include;.\Middle\Freertos\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./Start/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group hardware
    ./hardware/: delay.c delay.h uart.c uart.h I2C.c I2C.h key.c key.h i2s.c i2s3.c i2s3.h i2s.h
  group TinyUSB
    ./hardware/TinyUSB/: usb_descriptors.c usb_descriptors.h usb_audio.c usb_audio.h tusb_config.h
    ./hardware/TinyUSB/tinyusb/src/: tusb.c
    ./hardware/TinyUSB/tinyusb/src/common/: tusb_fifo.c
    ./hardware/TinyUSB/tinyusb/src/device/: usbd.c
    ./hardware/TinyUSB/tinyusb/src/class/audio/: audio_device.c
    ./hardware/TinyUSB/tinyusb/src/class/hid/: hid_device.c
    ./hardware/TinyUSB/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c fsdev_common.c
  group Freertos
    ./Middle/Freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./Middle/Freertos/portable/GCC/ARM_CM3/: port.c
    ./Middle/Freertos/portable/MemMang/: heap_4.c
